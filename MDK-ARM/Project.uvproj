# Keil uVision project Project.uvproj, settings and files
target hot-foot (ARM-ADS)
  device: STM32F051C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32f051 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F0XX, USE_DEFAULT_TIMEOUT_CALLBACK
  c include: ..\usr;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group usr
    ../usr/: eeprom.c flash_eep.c main.c stm32f0xx_it.c system_stm32f0xx.c tm1640.c crc16.c uart.c led.c mma8451.c misc.c
  group mdk
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
  group lib
    ../lib/: STM32f051.lib
